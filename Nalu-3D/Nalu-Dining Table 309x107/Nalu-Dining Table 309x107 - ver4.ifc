Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Nalu-Dining Table 309x107 - ver4.ifc
Time: 2024-10-24T09:10:22
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (144)
Name
 | Nalu-Dining Table 309x107_0 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_1 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_2 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_3 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_4 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_5 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_6 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_7 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_8 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_9 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_10 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_11 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_12 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_13 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_14 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_15 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_16 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_17 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_18 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_19 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_20 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_21 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_22 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_23 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_24 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_25 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_26 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_27 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_28 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_29 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_30 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_31 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_32 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_33 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_34 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_35 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_36 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_37 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_38 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_39 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_40 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_41 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_42 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_43 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_44 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_45 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_46 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_47 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_48 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_49 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_50 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_51 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_52 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_53 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_54 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_55 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_56 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_57 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_58 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_59 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_60 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_61 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_62 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_63 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_64 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_65 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_66 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_67 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_68 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_69 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_70 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_71 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_72 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_73 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_74 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_75 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_76 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_77 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_78 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_79 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_80 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_81 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_82 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_83 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_84 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_85 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_86 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_87 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_88 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_89 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_90 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_91 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_92 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_93 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_94 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_95 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_96 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_97 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_98 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_99 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_100 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_101 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_102 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_103 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_104 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_105 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_106 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_107 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_108 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_109 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_110 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_111 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_112 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_113 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_114 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_115 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_116 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_117 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_118 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_119 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_120 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_121 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_122 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_123 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_124 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_125 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_126 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_127 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_128 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_129 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_130 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_131 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_132 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_133 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_134 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_135 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_136 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_137 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_138 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_139 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_140 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_141 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_142 - ObjectType: SketchupGroup
 | Nalu-Dining Table 309x107_143 - ObjectType: SketchupGroup
